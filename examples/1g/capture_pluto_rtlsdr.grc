options:
  parameters:
    generate_options: qt_gui
    id: capture_pluto_rtlsdr
    output_language: python
    title: Capture PlutoSDR signal with RTL-SDR
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '403040000'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    comment: Correction offset PlutoSDR/RTL-SDR
    value: '365'
  states: {}
- name: phase_inc
  id: variable
  parameters:
    comment: Phase increment pour rotator
    value: 2*3.14159*freq_offset/samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1'
    comment: AGC pour stabiliser amplitude
    decay_rate: '1'
    gain: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: bypassed}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-70'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/fab2/Developpement/COSPAS-SARSAT/GNURADIO/gr-cospas/capture_pluto_rtlsdr_2.iq
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: 15 secondes = 6-7 bursts
    num_items: '37500000'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: Correction offset +365 Hz
    phase_inc: phase_inc
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Supprime DC offset
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: FFT Low Pass 450 kHz + décimation x2
    cutoff_freq: '500000'
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: ccf
    width: '100000'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: center_freq
    fftsize: '4096'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"0"'
    bb_gain0: '30'
    dc_offset_mode0: '1'
    freq0: center_freq
    gain0: '60'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', analog_agc2_xx_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
