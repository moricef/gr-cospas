options:
  parameters:
    description: Décodeur COSPAS-SARSAT pour fichiers I/Q Matlab (40 kHz)
    generate_options: no_gui
    id: decode_matlab_iq
    output_language: python
    run_options: run
    title: Décodeur COSPAS-SARSAT Matlab I/Q
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded_output.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fab2/Developpement/COSPAS-SARSAT/balise_406MHz/sarsat-main/beacon_signal_406mhz_long_msg_144bit.iq
    repeat: 'False'
    type: complex
  states: {}
- name: cospas_cospas_sarsat_decoder_0
  id: cospas_cospas_sarsat_decoder
  parameters:
    debug_mode: 'True'
    sample_rate: sample_rate
  states: {}

connections:
- [blocks_file_source_0, '0', cospas_cospas_sarsat_decoder_0, '0']
- [cospas_cospas_sarsat_decoder_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
