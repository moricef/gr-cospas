options:
  parameters:
    description: Décodeur COSPAS-SARSAT avec interface graphique
    generate_options: qt_gui
    id: decode_matlab_iq_gui
    output_language: python
    title: Décodeur COSPAS-SARSAT GUI
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded_output.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fab2/Developpement/COSPAS-SARSAT/balise_406MHz/sarsat-main/beacon_signal_406mhz_long_msg_144bit.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: cospas_cospas_sarsat_decoder_0
  id: cospas_cospas_sarsat_decoder
  parameters:
    debug_mode: 'True'
    sample_rate: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Données décodées
    name: '"Octets d\xE9cod\xE9s (0-255)"'
    size: '200'
    srate: '400'
    type: float
    ylabel: Valeur (0-255)
    ymax: '255'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    name: '"Signal I/Q 40 kHz"'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', cospas_cospas_sarsat_decoder_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [cospas_cospas_sarsat_decoder_0, '0', blocks_file_sink_0, '0']
- [cospas_cospas_sarsat_decoder_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
