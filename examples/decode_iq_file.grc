options:
  parameters:
    description: Décodeur COSPAS-SARSAT pour fichiers I/Q
    generate_options: no_gui
    id: decode_cospas_iq
    output_language: python
    run_options: run
    title: Décodeur COSPAS-SARSAT I/Q
  states: {}

blocks:
- name: input_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: target_rate
  id: variable
  parameters:
    value: '6400'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded_output.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fab2/Developpement/COSPAS-SARSAT/balise_406MHz/sarsat-main/beacon_signal_406mhz_long_msg_144bit.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: input_rate
    type: complex
  states: {}
- name: cospas_cospas_sarsat_decoder_0
  id: cospas_cospas_sarsat_decoder
  parameters:
    debug_mode: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: input_rate
    interp: target_rate
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [cospas_cospas_sarsat_decoder_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', cospas_cospas_sarsat_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
